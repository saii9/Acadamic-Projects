CIRCUIT C:\Users\SUNNY\simulations\Export Microwind\writecircuit.MSK
*
* IC Technology: CMOS 50nm - 7 Metal
*
VDD 1 0 DC 0.50
*
* List of nodes
* "N3" corresponds to n°3
* "N5" corresponds to n°5
* "N6" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "D7" corresponds to n°48
* "D6" corresponds to n°49
*
* MOS devices
MN1 19 38 35 0 N1  W= 0.10U L= 0.05U
MN2 18 38 34 0 N1  W= 0.10U L= 0.05U
MN3 17 39 33 0 N1  W= 0.10U L= 0.05U
MN4 16 39 32 0 N1  W= 0.10U L= 0.05U
MN5 15 41 31 0 N1  W= 0.10U L= 0.05U
MN6 14 41 30 0 N1  W= 0.10U L= 0.05U
MN7 13 52 29 0 N1  W= 0.10U L= 0.05U
MN8 12 52 28 0 N1  W= 0.10U L= 0.05U
MN9 11 45 27 0 N1  W= 0.10U L= 0.05U
MN10 10 45 26 0 N1  W= 0.10U L= 0.05U
MN11 9 46 25 0 N1  W= 0.10U L= 0.05U
MN12 8 46 24 0 N1  W= 0.10U L= 0.05U
MN13 7 50 23 0 N1  W= 0.10U L= 0.05U
MN14 6 50 22 0 N1  W= 0.10U L= 0.05U
MN15 5 47 21 0 N1  W= 0.10U L= 0.05U
MN16 3 47 20 0 N1  W= 0.10U L= 0.05U
MN17 0 5 3 0 N1  W= 0.10U L= 0.05U
MN18 0 48 5 0 N1  W= 0.10U L= 0.05U
MN19 0 7 6 0 N1  W= 0.10U L= 0.05U
MN20 0 49 7 0 N1  W= 0.10U L= 0.05U
MN21 0 9 8 0 N1  W= 0.10U L= 0.05U
MN22 0 43 9 0 N1  W= 0.10U L= 0.05U
MN23 0 11 10 0 N1  W= 0.10U L= 0.05U
MN24 0 44 11 0 N1  W= 0.10U L= 0.05U
MN25 0 13 12 0 N1  W= 0.10U L= 0.05U
MN26 0 51 13 0 N1  W= 0.10U L= 0.05U
MN27 0 15 14 0 N1  W= 0.10U L= 0.05U
MN28 0 42 15 0 N1  W= 0.10U L= 0.05U
MN29 0 17 16 0 N1  W= 0.10U L= 0.05U
MN30 0 40 17 0 N1  W= 0.10U L= 0.05U
MN31 0 19 18 0 N1  W= 0.10U L= 0.05U
MN32 0 37 19 0 N1  W= 0.10U L= 0.05U
MP1 1 5 3 1 P1  W= 0.15U L= 0.05U
MP2 1 48 5 1 P1  W= 0.15U L= 0.05U
MP3 1 7 6 1 P1  W= 0.15U L= 0.05U
MP4 1 49 7 1 P1  W= 0.15U L= 0.05U
MP5 1 9 8 1 P1  W= 0.15U L= 0.05U
MP6 1 43 9 1 P1  W= 0.15U L= 0.05U
MP7 1 11 10 1 P1  W= 0.15U L= 0.05U
MP8 1 44 11 1 P1  W= 0.15U L= 0.05U
MP9 1 13 12 1 P1  W= 0.15U L= 0.05U
MP10 1 51 13 1 P1  W= 0.15U L= 0.05U
MP11 1 15 14 1 P1  W= 0.15U L= 0.05U
MP12 1 42 15 1 P1  W= 0.15U L= 0.05U
MP13 1 17 16 1 P1  W= 0.15U L= 0.05U
MP14 1 40 17 1 P1  W= 0.15U L= 0.05U
MP15 1 19 18 1 P1  W= 0.15U L= 0.05U
MP16 1 37 19 1 P1  W= 0.15U L= 0.05U
*
C2 1 0  1.262fF
C3 3 0  0.404fF
C4 1 0  1.813fF
C5 5 0  0.333fF
C6 6 0  0.404fF
C7 7 0  0.333fF
C8 8 0  0.404fF
C9 9 0  0.333fF
C10 10 0  0.404fF
C11 11 0  0.333fF
C12 12 0  0.404fF
C13 13 0  0.333fF
C14 14 0  0.404fF
C15 15 0  0.333fF
C16 16 0  0.404fF
C17 17 0  0.333fF
C18 18 0  0.404fF
C19 19 0  0.333fF
C20 20 0  0.414fF
C21 21 0  0.406fF
C22 22 0  0.414fF
C23 23 0  0.406fF
C24 24 0  0.414fF
C25 25 0  0.406fF
C26 26 0  0.414fF
C27 27 0  0.406fF
C28 28 0  0.414fF
C29 29 0  0.406fF
C30 30 0  0.414fF
C31 31 0  0.406fF
C32 32 0  0.414fF
C33 33 0  0.406fF
C34 34 0  0.414fF
C35 35 0  0.406fF
C37 37 0  0.005fF
C38 38 0  0.002fF
C39 39 0  0.002fF
C40 40 0  0.005fF
C41 41 0  0.002fF
C42 42 0  0.005fF
C43 43 0  0.005fF
C44 44 0  0.005fF
C45 45 0  0.002fF
C46 46 0  0.002fF
C47 47 0  0.002fF
C48 48 0  0.005fF
C49 49 0  0.005fF
C50 50 0  0.002fF
C51 51 0  0.005fF
C52 52 0  0.002fF
*
* n-MOS Model 3 :
* Standard
.MODEL N1 NMOS LEVEL=3 VTO=0.20 UO=600.000 TOX= 1.8E-9
+LD =0.005U THETA=0.300 GAMMA=0.400
+PHI=0.150 KAPPA=0.010 VMAX=130.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* Standard
.MODEL P1 PMOS LEVEL=3 VTO=-0.20 UO=200.000 TOX= 1.8E-9
+LD =0.005U THETA=0.300 GAMMA=0.400
+PHI=0.150 KAPPA=0.010 VMAX=100.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.1N 5.00N
* (Pspice)
.PROBE
.END
